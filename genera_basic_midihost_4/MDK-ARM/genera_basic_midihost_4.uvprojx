# Keil uVision project genera_basic_midihost_4.uvprojx, settings and files
target genera_basic_midihost_4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F765VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: genera_basic_midihost_4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F765xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f765xx.s
  group Application/User
    ../Src/: usb_host.c main.c usbh_conf.c stm32f7xx_hal_msp.c stm32f7xx_it.c audiostream.c codec.c MIDI_application.c OOPS.c OOPSDelay.c OOPSFilter.c OOPSInstrument.c OOPSMath.c OOPSOscillator.c OOPSReverb.c OOPSUtilities.c OOPSWavetables.c usbh_MIDI.c
    ../Inc/: audiostream.h codec.h main.h MIDI_application.h OOPS.h OOPSCore.h OOPSDelay.h OOPSFilter.h OOPSInstrument.h OOPSMath.h OOPSMemConfig.h OOPSOscillator.h OOPSReverb.h OOPSTest.h OOPSUtilities.h OOPSWavetables.h stm32f7xx_hal_conf.h stm32f7xx_it.h usb_host.h usbh_conf.h usbh_MIDI.h
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_ctlreq.c usbh_pipes.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal.c stm32f7xx_ll_usb.c stm32f7xx_hal_hcd.c stm32f7xx_hal_sai.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c_ex.c
software components: CMSIS:CORE 4.1.0
